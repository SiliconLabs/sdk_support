# IAR project iec60335_classb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\CM3\CoreSupport; ..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32\startup\iar; ..\..\..\..\efm32lib\inc; ..\..\..\..\iec60335_classb\inc; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iec60335_classb.bin
  ILINK.IlinkOutputFile: iec60335_classb.out
  ILINK.IlinkIcfFile: EFM32G890F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\CM3\CoreSupport; ..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\..\..\efm32lib\inc; ..\..\..\bsp; ..\..\..\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/startup/iar/: startup_efm32.s
    ../../../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
  group EFM32Lib
    ../../../../efm32lib/src/: efm32_acmp.c efm32_adc.c efm32_aes.c efm32_assert.c efm32_cmu.c efm32_dac.c efm32_dbg.c efm32_dma.c efm32_ebi.c efm32_emu.c efm32_gpio.c efm32_i2c.c efm32_lcd.c efm32_letimer.c efm32_leuart.c efm32_mpu.c efm32_msc.c efm32_pcnt.c efm32_prs.c efm32_rmu.c efm32_rtc.c efm32_system.c efm32_timer.c efm32_usart.c efm32_vcmp.c efm32_wdog.c
    ../source/: efm32g890f128_interrupt.c
  group IEC60335
    ../../../../iec60335_classb/src/: iec60335_class_b_cpureg_test.c iec60335_class_b_cpureg_test_bist_iar.s iec60335_class_b_cpureg_test_post_iar.s iec60335_class_b_critical_data.c iec60335_class_b_flash_test.c iec60335_class_b_interrupt_test.c iec60335_class_b_post.c iec60335_class_b_programcounter_test.c iec60335_class_b_ram_test.c iec60335_class_b_timer_rtc_test.c iec60335_class_b_wdt_test.c
  group Source
    ../source/: dvk_spi.c main.c
