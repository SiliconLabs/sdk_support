# Keil uVision project iec60355-example.uvproj, settings and files
target iec60355_classb_example (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: iec60355-example
  c flags: Optim=1
  c define: EFM32G890F128 __CC_ARM
  c misc: --enum_is_int
  c include: ..\source;..\..\..\..\CMSIS\CM3\CoreSupport;..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32;..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32\startup\arm;..\..\..\..\efm32lib\inc;..\..\..\..\iec60335_classb\inc;..\..\..\drivers
  asm define: EFM32G890F128
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\iec60355-example.sct
  link misc: --symdefs=iec60355-example.symdef
  group CMSIS
    ../../../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
    ../../../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/startup/arm/: startup_efm32.s
  group EFM32_Lib
    ../../../../efm32lib/src/: efm32_acmp.c efm32_adc.c efm32_aes.c efm32_assert.c efm32_cmu.c efm32_dac.c efm32_dbg.c efm32_dma.c efm32_ebi.c efm32_emu.c efm32_gpio.c efm32_i2c.c efm32_lcd.c efm32_letimer.c efm32_leuart.c efm32_mpu.c efm32_msc.c efm32_pcnt.c efm32_prs.c efm32_rmu.c efm32_rtc.c efm32_system.c efm32_timer.c efm32_usart.c efm32_vcmp.c efm32_wdog.c
    ../source/: efm32g890f128_interrupt.c
  group IEC60355_Lib
    ../../../../iec60335_classb/src/: iec60335_class_b_cpureg_test.c iec60335_class_b_critical_data.c iec60335_class_b_flash_test.c iec60335_class_b_interrupt_test.c iec60335_class_b_programcounter_test.c iec60335_class_b_ram_test.c iec60335_class_b_timer_rtc_test.c iec60335_class_b_cpureg_test_bist_arm.s iec60335_class_b_cpureg_test_post_arm.s iec60335_class_b_post.c iec60335_class_b_wdt_test.c
  group Source
    ../Source/: main.c
    ./: iec60355-example.map iec60355-example.sct
    ../source/: dvk_spi.c
