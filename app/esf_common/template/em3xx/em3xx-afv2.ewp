# IAR project em3xx-afv2.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--partNumber;U--$; PHY_EM3XX; ATTRIBUTE_STORAGE_CONFIGURATION="$--deviceName--$_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="$--deviceName--$.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily;L--$\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--partNumber;U--$; PHY_EM3XX; ATTRIBUTE_STORAGE_CONFIGURATION="$--deviceName--$_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="$--deviceName--$.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily;L--$\Include
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$--studioInstallationPath--$'
  postbuild: $--deviceName--$-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$--studioInstallationPath--$'
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1; SIMEEPROM_SIZE=$--simeepromSize--$; PSSTORE_SIZE=$--psstoreSize--$; LONGTOKEN_SIZE=$--longTokenSize--$; HEADER_SIZE=$--headerSize--$
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\em35x\$--partNumber;L--$\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: znet-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c znet-cli.c
    $--halDirFromProjFs--$/micro/cortexm3/: assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c token.c uart.c ext-device.c spi-master.c
    $--halDirFromProjFs--$/plugin/buzzer/: buzzer-em3xx.c
    $--frameworkDirFromProjFs--$/../util/serial/: command-interpreter2.c
    $--halDirFromProjFs--$/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    $--frameworkDirFromProjFs--$/../../stack/config/: ember-configuration.c
    $--halDirFromProjFs--$/: ember-base-configuration.c
    $--frameworkDirFromProjFs--$/../util/common/: library.c
    $--frameworkDirFromProjFs--$/../util/security/: security-address-cache.c
    $--halDirFromProjFs--$/plugin/serial/: serial.c
    $--halDirFromProjFs--$/micro/cortexm3/usb/: em_usbd.c em_usbtimer.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c
    $--halDirFromProjFs--$/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    $--frameworkDirFromProjFs--$/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
